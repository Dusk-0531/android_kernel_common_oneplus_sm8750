## drivers/changer/Kconfig
```kconfig
# SPDX-License-Identifier: GPL-2.0
config CCCV
	tristate "Constant Current-Constant Voltage Charging"
	default y
```
